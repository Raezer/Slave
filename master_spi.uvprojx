# Keil uVision project master_spi.uvprojx, settings and files
target stm32f417 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F417ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: master_spi
  c flags: Optim=1 wLevel=2
  c define: inline=__inline,USE_STDPERIPH_DRIVER, STM32F40XX
  c misc: --exceptions --diag_suppress=368
  c include: .\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries;.\Libraries\mbed\hal;.\Libraries\mbed\api;.\Libraries\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F4XX;.\Libraries\mbed\targets\hal\TARGET_STM\TARGET_STM32F4XX;.\Libraries\tm_libraries;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/: main.c Config.c AdisRecv.cpp
  group startup
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group system
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group periferals
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_rcc.c stm32f4xx_tim.c
  group mbed
    ./Libraries/mbed/common/: assert.c board.c error.c gpio.c pinmap_common.c us_ticker_api.c SPI.cpp wait_api.c SPISlave.cpp
    ./Libraries/mbed/targets/cmsis/TARGET_STM/TARGET_STM32F4XX/: cmsis_nvic.c
    ./Libraries/mbed/targets/hal/TARGET_STM/TARGET_STM32F4XX/: us_ticker.c spi_api.c pinmap.c gpio_api.c
